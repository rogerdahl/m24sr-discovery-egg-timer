# Keil uVision project Project.uvproj, settings and files
target STM32F40_41xxx (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: M24SR_DISCOVERY_MB1138_FOR_F4 +hex
  c flags: Optim=1 OneElfS=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,USE_STM324xG_EVAL,USE_FULL_ASSERT
  c misc: --C99
  c include: ..\..\..\..\..\Libraries\CMSIS\Core\CM3;..\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\..\Utilities\M24SR_DISCOVERY_MB1138\LED\inc;..\..\..\..\..\Utilities\M24SR_DISCOVERY_MB1138\LCD\inc;..\..\..\..\..\Utilities\M24SR_DISCOVERY_MB1138\BLUETOOTH\inc;..\..\..\..\..\Utilities\M24SR_DISCOVERY_MB1138\LCD\pictures;..\..\..\..\..\Libraries\M24SR\inc;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group User_Appli
    ../src/: main.c menu.c hw_config.c stm32f4xx_it.c
  group M24SR_Driver
    ../../../../../Libraries/M24SR/src/: drv_I2C_M24SR.c drv_M24SR.c
  group M24SR_Libraries
    ../../../../../Libraries/M24SR/src/: lib_M24SR.c
  group NFC_Libraries
    ../../../../../Libraries/M24SR/src/: lib_TagType4.c lib_NDEF_URI.c lib_NDEF_SMS.c lib_NDEF_Email.c lib_NDEF_Vcard.c lib_NDEF_Geo.c lib_NDEF_MyApp.c lib_NDEF_AAR.c lib_NDEF.c lib_ISO7816_Password.c lib_STProprietary_feature.c
  group StdPeriph_Driver
    ../../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_flash.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_rtc.c stm32f4xx_syscfg.c
  group User_Driver
    ../../../../../Utilities/M24SR_DISCOVERY_MB1138/LED/src/: drv_LED.c
    ../../../../../Utilities/M24SR_DISCOVERY_MB1138/LCD/src/: drv_lcdspi_ili9341.c
    ../../../../../Utilities/M24SR_DISCOVERY_MB1138/BLUETOOTH/src/: drv_bluetooth.c
  group MDK-ARM
    ./: startup_stm32f40_41xxx.s
  group CMSIS
    ../src/: system_stm32f4xx.c
